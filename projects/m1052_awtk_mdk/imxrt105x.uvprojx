# Keil uVision project imxrt105x.uvprojx, settings and files
target Debug sdram (5060020::V5.06 (build 20)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imxrt105x +hex
  AfterMake: fromelf.exe --m32 Objects\Debug_sdram\imxrt105x.axf -o Objects\Debug_sdram\imxrt105x.srec
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AW_CORTEX_M7, AW_VDEBUG_INFO,AW_VDEBUG,CODE_IN_SDRAM,HAS_AWTK_CONFIG,AW_FB_VERSIONS_N1
  c include: ..\..\aworks_sdk\include\config;..\..\aworks_sdk\source\bsp\imx1050;..\..\aworks_sdk\apollo\components\lora\lora_softimer\include;..\..\aworks_sdk\apollo\3rdparty\sqlite3;..\..\aworks_sdk\apollo\components\lora\lora_sx1276\include;..\..\aworks_sdk\apollo\components\lora\lora_utilities\include;..\..\aworks_sdk\apollo\components\lora\loranet_stack\include;..\..\aworks_sdk\apollo\components\net\modbus\include;..\..\aworks_sdk\apollo\components\net\goahead-2.5_adapter\include;..\..\aworks_sdk\apollo\components\usb\config;..\..\aworks_sdk\apollo\components\net\ftpd\include\ftpd;..\..\aworks_sdk\apollo\3rdparty\net\goahead-2.5;..\..\aworks_sdk\apollo\3rdparty\fs\yaffs2_e57244d\direct;..\..\aworks_sdk\apollo\components\usb\include;..\..\aworks_sdk\apollo\components\fs\yaffs2_e57244d_adapter\include;..\..\aworks_sdk\apollo\components\fs\lffs\include;..\..\aworks_sdk\apollo\3rdparty\fs\fatfs\src;..\..\aworks_sdk\apollo\components\fs\fatfs_adapter\include;..\..\aworks_sdk\apollo\components\net\tools\config;..\..\aworks_sdk\apollo\components\shell\include;..\..\aworks_sdk\source\cpu\imx1050\source\awsa\config;..\..\aworks_sdk\apollo\components\shell\config;..\..\aworks_sdk\apollo\components\fb\include;..\..\aworks_sdk\source\cpu\imxrt10xx_common\include;..\..\aworks_sdk\apollo\components\net\core\include;..\..\aworks_sdk\apollo\components\net\dhcp_server\include;..\..\aworks_sdk\apollo\components\net\ping\include;..\..\aworks_sdk\apollo\components\net\lwip_2.x_adapter\include;..\..\aworks_sdk\apollo\interface\include;..\..\aworks_sdk\apollo\rtk\include;..\..\aworks_sdk\apollo\rtk\include\arch\arm\cortex-m7;..\..\aworks_sdk\apollo\rtk\config;..\..\aworks_sdk\apollo\psp\rtk\include;..\..\aworks_sdk\apollo\psp\rtk\config;..\..\aworks_sdk\apollo\components\awbus_lite\include;..\..\aworks_sdk\apollo\components\awbus_lite\config;..\..\aworks_sdk\apollo\components\base\include;..\..\aworks_sdk\apollo\components\base\config;..\..\aworks_sdk\resources\firmware;..\..\aworks_sdk\apollo\3rdparty\net\lwip_2.x\src\include;..\..\aworks_sdk\apollo\3rdparty\net\lwip_2.x\src\include\ipv4;..\..\aworks_sdk\apollo\3rdparty\net\lwip_2.x\src\netif;..\..\aworks_sdk\apollo\3rdparty\can_stack\CanFestival-3.8\include;.\user_config;.\user_code;.\user_config\awbl_hwconf_usrcfg;.\user_config\emWin522_Config;..\m1052_awtk\user_config;..\m1052_awtk\user_config\awbl_hwconf_usrcfg;..\..\aworks_sdk\resources\firmware;..\..\aworks_sdk\apollo\components\can_stack\CanFestival-3.8_adapter;..\..\aworks_sdk\apollo\components\can_stack\CanFestival-3.8_adapter\inc;..\..\aworks_sdk\apollo\components\CANopen;..\..\aworks_sdk\apollo\components\net\ftpd\include;..\..\aworks_sdk\apollo\components\net\ftpd\include\ftpd;..\..\aworks_sdk\apollo\resources\firmware;..\..\aworks_sdk\apollo\interface\posix\sys;..\..\aworks_sdk\source\imxrt10xx_common\include;..\..\aworks_sdk\source\imxrt10xx_common\board\imxrt105x\cpu\include;..\..\aworks_sdk\source\imxrt10xx_common\board\imxrt105x\cpu\source\awsa\include;..\..\aworks_sdk\source\imxrt10xx_common\board\imxrt105x\cpu\source\awsa\config;..\..\aworks_sdk\source\imxrt10xx_common\board\imxrt105x\bsp;..\..\aworks_awtk_rt1052\awtk-sdk\awtk\src;..\..\aworks_awtk_rt1052\awtk-sdk\awtk\src\ext_widgets;..\..\aworks_awtk_rt1052\awtk-sdk\awtk\3rd;..\..\aworks_awtk_rt1052\awtk-sdk\awtk\3rd\agge;..\..\aworks_awtk_rt1052\awtk-sdk\awtk\3rd\nanovg;..\..\aworks_awtk_rt1052\awtk-sdk\awtk\3rd\nanovg\base;..\..\aworks_awtk_rt1052\awtk-sdk\awtk\3rd\gpinyin\include;..\..\aworks_awtk_rt1052\awtk-sdk\awtk\3rd\libunibreak;..\..\aworks_awtk_rt1052\awtk-port
  asm include: ..\examples\peripheral\sai
  scatter file: .\imxrt105x_sdram.sct
  link misc: --remove --entry=Reset_Handler --verbose
  group user_code
    ../m1052_awtk/user_code/: main.c awtk_demo.c touch_calibration.c
  group user_config
    ./user_config/: flexram_config_for_armcc.S
    ../m1052_awtk/user_config/: aw_demo_config.h aw_prj_config.c aw_prj_param_auto_cfg.h aw_prj_params.h aw_prj_usr_app_init.c
  group awbl_hwconf_usrcfg
    ../m1052_awtk/user_config/awbl_hwconf_usrcfg/: awbl_hwconf_bu21029muv.h awbl_hwconf_buzzer_pwm.h awbl_hwconf_csm300x.h awbl_hwconf_cyw43362.c awbl_hwconf_cyw43362_wifi_spi.h awbl_hwconf_dp83848_phy.h awbl_hwconf_fb.h awbl_hwconf_fm175xx_spi.h awbl_hwconf_ft5x06.h awbl_hwconf_gpio_i2c0.h awbl_hwconf_gpio_key.h awbl_hwconf_gpio_led.h awbl_hwconf_gpio_wdt.h awbl_hwconf_gprs_me909s.h awbl_hwconf_gprs_sim800.h awbl_hwconf_gprs_u9300c.h awbl_hwconf_imx1050_acmp1.h awbl_hwconf_imx1050_adc1.h awbl_hwconf_imx1050_adc2.h awbl_hwconf_imx1050_csi.h awbl_hwconf_imx1050_edma.h awbl_hwconf_imx1050_eflex_pwm1.h awbl_hwconf_imx1050_eflex_pwm4.h awbl_hwconf_imx1050_enc1.h awbl_hwconf_imx1050_enet.h awbl_hwconf_imx1050_flexcan1.h awbl_hwconf_imx1050_flexcan2.h awbl_hwconf_imx1050_flexspi.h awbl_hwconf_imx1050_gpio.h awbl_hwconf_imx1050_gpt1.h awbl_hwconf_imx1050_gpt2.h awbl_hwconf_imx1050_lpi2c1.h awbl_hwconf_imx1050_lpi2c2.h awbl_hwconf_imx1050_lpspi1.h awbl_hwconf_imx1050_lpspi2.h awbl_hwconf_imx1050_lpspi3.h awbl_hwconf_imx1050_lpspi4.h awbl_hwconf_imx1050_lpuart1.h awbl_hwconf_imx1050_lpuart2.h awbl_hwconf_imx1050_lpuart3.h awbl_hwconf_imx1050_lpuart4.h awbl_hwconf_imx1050_lpuart5.h awbl_hwconf_imx1050_lpuart6.h awbl_hwconf_imx1050_lpuart7.h awbl_hwconf_imx1050_lpuart8.h awbl_hwconf_imx1050_mqs.h awbl_hwconf_imx1050_nandflash_mx30lf1g08.h awbl_hwconf_imx1050_nandflash_s34ml01g2.h awbl_hwconf_imx1050_nandflash_s34ml02g2.h awbl_hwconf_imx1050_nvic.h awbl_hwconf_imx1050_ocotp.h awbl_hwconf_imx1050_pit.h awbl_hwconf_imx1050_qtimer3_cap.h awbl_hwconf_imx1050_qtimer3_pwm.h awbl_hwconf_imx1050_qtimer3_timer0.h awbl_hwconf_imx1050_rtc.h awbl_hwconf_imx1050_rtwdt.h awbl_hwconf_imx1050_sai1.h awbl_hwconf_imx1050_sai3.h awbl_hwconf_imx1050_sdio_sd0.h awbl_hwconf_imx1050_semc.h awbl_hwconf_imx1050_tempmon.h awbl_hwconf_imx1050_ts.h awbl_hwconf_imx1050_usbd.h awbl_hwconf_imx1050_usbh1.h awbl_hwconf_imx1050_usbh2.h awbl_hwconf_imx1050_wdt1.h awbl_hwconf_ov7725.h awbl_hwconf_pcf85063.h awbl_hwconf_pcf85263.h awbl_hwconf_sx127x.h awbl_hwconf_ublox.h awbus_lite_hwconf_usrcfg.c awbl_hwconf_ap_tft7_0.h awbl_hwconf_cyw43362_wifi_sdio.h awbl_hwconf_gc0308.h awbl_hwconf_gc0328.h awbl_hwconf_imx1050_sdio_sd1.h awbl_hwconf_imx1050_zsn603_i2c.h awbl_hwconf_imx1050_zsn603_uart.h awbl_hwconf_lcd_640480w056tr.h awbl_hwconf_lcd_800600w080tr.h awbl_hwconf_lcd_tm070rdh12_24b.h awbl_hwconf_sensor_bh1730.h awbl_hwconf_sensor_bma253.h awbl_hwconf_sensor_bme280.h awbl_hwconf_sensor_bmg160.h awbl_hwconf_sensor_bmp280.h awbl_hwconf_sensor_hts221.h awbl_hwconf_sensor_lis3mdl.h awbl_hwconf_sensor_lps22hb.h awbl_hwconf_sensor_lsm6dsl.h awbl_hwconf_sensor_ltr553.h awbl_hwconf_sensor_mmc5883ma.h awbl_hwconf_sensor_shtc1.h awbl_hwconf_tft_4_3.h
  group lib
    ../../aworks_sdk/lib/Release/: am_smf.lib aw_base.lib aw_bsp.lib aw_cjson_2_0_0.lib aw_clk_framework.lib aw_cpu.lib aw_fatfs.lib aw_fatfs_adapter.lib aw_ftpd.lib aw_goahead.lib aw_lffs.lib aw_loranet.lib aw_loranet_adapter.lib aw_lwip_2_x.lib aw_lwip_2_x_adapter.lib aw_lwip_2_x_ext.lib aw_modbus.lib aw_net_core.lib aw_net_tools.lib aw_psp.lib aw_shell.lib aw_smf_adapter.lib aw_sqlite3_adapter.lib aw_unity.lib aw_usb.lib aw_yaffs.lib awbl_common.lib awbl_core.lib awbl_stack_overflow.lib firmware_cyw43362.lib lua_5_3_4.lib lua_5_3_4_adapter.lib reqsched.lib rtk.lib zlib_1_2_11_adapter.lib aw_canfestival_3_8_adapter.lib
    ../../aworks_awtk_rt1052/scons_lib/lib/: awtk_imx1050.lib
  group my_libc
    ./my_libc/: asctime_r.c strnlen.c detection.c heap.c gmtime_r.c sys_exit.c libspace.c mutex.c
  group awtk-port
    ../../aworks_awtk_rt1052/awtk-port/: fs_os.c lcd_aworks.c main_loop_aworks.c mutex_null.c platform.c rt1052_g2d.c thread.c
  group demo
    ../../aworks_awtk_rt1052/awtk-sdk/awtk/demos/: assets.c demo_ui_app.c
target Release sdram (5060020::V5.06 (build 20)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imxrt105x +hex
  AfterMake: fromelf.exe --m32 Objects\Release_sdram\imxrt105x.axf -o Objects\Release_sdram\imxrt105x.srec
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: as above
  asm include: ..\examples\peripheral\sai
  scatter file: .\imxrt105x_sdram.sct
  link misc: --remove --entry=Reset_Handler --verbose
target Debug flexspi flash (5060020::V5.06 (build 20)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imxrt105x +hex
  AfterMake: fromelf.exe --m32 Objects\Debug_flexspi_flash\imxrt105x.axf -o Objects\Debug_flexspi_flash\imxrt105x.srec
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AW_CORTEX_M7, AW_VDEBUG_INFO,AW_VDEBUG,CODE_IN_QSPI_FLASH,HAS_AWTK_CONFIG,AW_FB_VERSIONS_N1
  c include: as above
  asm include: ..\examples\peripheral\sai
  scatter file: .\imxrt105x_flexspi_flash.sct
  link misc: --remove --entry=Reset_Handler --verbose
target Release flexspi flash (5060020::V5.06 (build 20)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: imxrt105x +hex
  AfterMake: fromelf.exe --m32 Objects\Release_flexspi_flash\imxrt105x.axf -o Objects\Release_flexspi_flash\imxrt105x.srec
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: as above
  asm include: ..\examples\peripheral\sai
  scatter file: .\imxrt105x_flexspi_flash.sct
  link misc: --remove --entry=Reset_Handler --verbose
